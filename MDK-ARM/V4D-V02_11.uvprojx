# Keil uVision project V4D-V02_11.uvprojx, settings and files
target V4D-V02_11 (5060960::V5.06 update 7 (build 960)::.\ARM_compiler_506)
  device: STM32F091VC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: V4D-V02_11 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC
  c include: ../Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;          ../Drivers/CMSIS/Include;          ..\STM32_SelfTest_Library\inc;          C:\Keil_5_36\Arm_Packs\Keil\STM32F0xx_DFP\2.1.0;          C:\Keil_5_36\Arm_Packs\Keil\STM32F0xx_DFP\2.1.0\CMSIS\Flash;          C:\Keil_5_36\Arm_Packs\Keil\STM32F0xx_DFP\2.0.0\CMSIS\Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\STM32_SelfTest_Library\Boot_Flash_ClassB.sct
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_adc.c stm32f0xx_hal_i2c.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_wwdg.c stm32f0xx_hal_crc.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c adap_run_time.c control_motor_relays.c delay_us.c display_keypad.c encoder.c eprom.c error_codes.c Global_Var.c inout.c interpreter.c last_error_upd.c learning.c modbus.c custom_inverter.c mtimer.c push_code_req.c read_ad_inputs.c req_photo_learn.c req_status_wanted.c start_ini.c main.c stm32f0xx_it.c inverter_safety.c
  group STM32_SelfTest_Library
    ../STM32_SelfTest_Library/src/: stm32fxx_STLclockrun.c stm32fxx_STLclockstart.c stm32fxx_STLcrc32Run.c stm32fxx_STLmain.c stm32fxx_STLstartup.c stm32fxx_STLtranspRam.c
  group STM32_SpecificSelfTests
    ../STM32_SelfTest_Library/: stm32f0xx_STLcpurunKEIL.s stm32f0xx_STLcpustartKEIL.s stm32fxx_STLRamMcMxKEIL.s
software components: CMSIS:CORE 5.5.0
